blocks:
- name: Picoscope4000
  id: fair::picoscope::Picoscope4000a<float32>
  parameters:
    acquisition_mode: Streaming
    auto_arm: 'true'
    channel_couplings: [DC, DC, DC, DC, DC, DC, DC, DC]
    channel_ids: [A, B, C, D, E, F, G, H]
    channel_names: [U1, U2, U3, I1, I2, I3, PicoG, TT]
    channel_ranges: ['5', '5', '5', '5', '5', '5', '5', '5']
    channel_units: [V, V, V, V, V, V, a.u, a.u]
    sample_rate: '1000'
  states: {}
- name: DummySinkPicoDigital
  id: gr::testing::TagSink<uint16, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: SinkA
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U1
  states: {}
- name: SinkB
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U2
  states: {}
- name: SinkC
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U3
  states: {}
- name: SinkD
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I1
  states: {}
- name: SinkE
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I2
  states: {}
- name: SinkF
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I3
  states: {}
- name: SinkG
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: PicoG
  states: {}
- name: SinkH
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: TT
  states: {}
- name: StreamToDataSetA
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetB
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetC
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetD
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetE
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetF
  id: gr::basic::StreamFilterImpl<float32>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: SinkDataSetA
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU1
  states: {}
- name: SinkDataSetB
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU2
  states: {}
- name: SinkDataSetC
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU3
  states: {}
- name: SinkDataSetD
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI1
  states: {}
- name: SinkDataSetE
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI2
  states: {}
- name: SinkDataSetF
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI3
  states: {}
- name: PowerMetrics
  id: gr::electrical::PowerMetrics<float32, 3>
  parameters:
    decim: '1'
  states: {}
- name: SystemUnbalance
  id: gr::electrical::SystemUnbalance<float32, 3>
  parameters: {}
  states: {}
- name: SinkTotalActivePower
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: TotalActivePower
  states: {}
- name: FrequencyEstimatorU1
  id: gr::filter::FrequencyEstimatorTimeDomain<float32>
  parameters: {}
  states: {}
- name: SinkFrequencyU1
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: FrequencyU1
  states: {}

connections:
- [Picoscope4000, '0', DummySinkPicoDigi0, '0']
- [Picoscope4000, ['1', '0'], SinkA, '0']
- [Picoscope4000, ['1', '0'], StreamToDataSetA, '0']
- [StreamToDataSetA, '0', SinkDataSetA, '0']
- [Picoscope4000, ['1', '0'], FrequencyEstimatorU1, '0']
- [FrequencyEstimatorU1, '0', SinkFrequencyU1, '0']
- [Picoscope4000, ['1', '1'], SinkB, '0']
- [Picoscope4000, ['1', '1'], StreamToDataSetB, '0']
- [StreamToDataSetB, '0', SinkDataSetB, '0']
- [Picoscope4000, ['1', '2'], SinkC, '0']
- [Picoscope4000, ['1', '2'], StreamToDataSetC, '0']
- [StreamToDataSetC, '0', SinkDataSetC, '0']
- [Picoscope4000, ['1', '3'], SinkD, '0']
- [Picoscope4000, ['1', '3'], StreamToDataSetD, '0']
- [StreamToDataSetD, '0', SinkDataSetD, '0']
- [Picoscope4000, ['1', '4'], SinkE, '0']
- [Picoscope4000, ['1', '4'], StreamToDataSetE, '0']
- [StreamToDataSetE, '0', SinkDataSetE, '0']
- [Picoscope4000, ['1', '5'], SinkF, '0']
- [Picoscope4000, ['1', '5'], StreamToDataSetF, '0']
- [StreamToDataSetF, '0', SinkDataSetF, '0']
- [Picoscope4000, ['1', '6'], SinkG, '0']
- [Picoscope4000, ['1', '7'], SinkH, '0']
- [Picoscope4000, ['1', '0'], PowerMetrics, ['0', '0']]
- [Picoscope4000, ['1', '1'], PowerMetrics, ['0', '1']]
- [Picoscope4000, ['1', '2'], PowerMetrics, ['0', '2']]
- [Picoscope4000, ['1', '3'], PowerMetrics, ['1', '0']]
- [Picoscope4000, ['1', '4'], PowerMetrics, ['1', '1']]
- [Picoscope4000, ['1', '5'], PowerMetrics, ['1', '2']]
- [PowerMetrics, ['3', '0'], SystemUnbalance, ['0', '0']]
- [PowerMetrics, ['3', '1'], SystemUnbalance, ['0', '1']]
- [PowerMetrics, ['3', '2'], SystemUnbalance, ['0', '2']]
- [PowerMetrics, ['4', '0'], SystemUnbalance, ['1', '0']]
- [PowerMetrics, ['4', '1'], SystemUnbalance, ['1', '1']]
- [PowerMetrics, ['4', '2'], SystemUnbalance, ['1', '2']]
- [PowerMetrics, ['0', '0'], SystemUnbalance, ['2', '0']]
- [PowerMetrics, ['0', '1'], SystemUnbalance, ['2', '1']]
- [PowerMetrics, ['0', '2'], SystemUnbalance, ['2', '2']]
- [SystemUnbalance, '0', SinkTotalActivePower, '0']

metadata:
  file_format: 1
