blocks:
- name: Picoscope4000
  id: fair::picoscope::Picoscope4000a
  parameters:
    acquisition_mode: Streaming
    auto_arm: 'true'
    channel_couplings: [DC_1M, DC_1M, DC_1M, DC_1M, DC_1M, DC_1M, DC_1M, DC_1M]
    channel_ids: [A, B, C, D, E, F, G, H]
    channel_names: [U1, U2, U3, I1, I2, I3, PicoG, TT]
    channel_ranges: ['5', '5', '5', '5', '5', '5', '5', '5']
    channel_units: [V, V, V, V, V, V, a.u, a.u]
    sample_rate: '10000'
  states: {}
- name: NullSinkB
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkC
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkD
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkE
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkF
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkG
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkH
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: ConvertA
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: SinkA
  id: gr::basic::DataSink
  parameters:
    signal_name: U1
  states: {}
- name: StreamToDataSetA
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: SinkDataSetA
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetU1
  states: {}

connections:
- [Picoscope4000, ['0', '0'], ConvertA, '0']
- [ConvertA, '0', SinkA, '0']
- [ConvertA, '0', StreamToDataSetA, '0']
- [StreamToDataSetA, '0', SinkDataSetA, '0']
- [Picoscope4000, ['0', '1'], NullSinkB, '0']
- [Picoscope4000, ['0', '2'], NullSinkC, '0']
- [Picoscope4000, ['0', '3'], NullSinkD, '0']
- [Picoscope4000, ['0', '4'], NullSinkE, '0']
- [Picoscope4000, ['0', '5'], NullSinkF, '0']
- [Picoscope4000, ['0', '6'], NullSinkG, '0']
- [Picoscope4000, ['0', '7'], NullSinkH, '0']

metadata:
  file_format: 1
