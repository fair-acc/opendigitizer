blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    sample_rate: '1000'
    verbose_console: 'false'
    repeat_period: '1900000000'
    chunk_size: '250'
    tag_times: ['300000000', '900000000', '1200000000']
    tag_values: [CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2']
  states: {}
- name: SignalGenerator1
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '30'
    amplitude: '50'
    sample_rate: '10000'
    signal_type: Sin
  states: {}
- name: FFT
  id: gr::blocks::fft::FFT<float32, gr::DataSet<float32>, gr::algorithm::FFT>
  parameters: {}
  states: {}
- name: StreamToDataSet1
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: CMD_DIAG_TRIGGER1
    n_pre: '200'
    n_post: '600'
  states: {}
- name: StreamToDataSet2
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: '[CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1, CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2]'
    n_pre: '100'
    n_post: '100'
  states: {}
- name: Sink1
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: Signal1
  states: {}
- name: SinkFFT1
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: SignalFFT1
  states: {}
- name: SinkDataSet1
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSet1
  states: {}
- name: SinkDataSet2
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSet2
  states: {}
- name: SinkTriggered
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: SignalTriggered
  states: {}
- name: SinkMultiplexed
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: SignalMultiplexed
  states: {}

connections:
- [ClockSource, '0', SignalGenerator1, '0']
- [SignalGenerator1, '0', FFT, '0']
- [FFT, '0', SinkFFT1, '0']
- [SignalGenerator1, '0', StreamToDataSet1, '0']
- [SignalGenerator1, '0', StreamToDataSet2, '0']
- [SignalGenerator1, '0', Sink1, '0']
- [StreamToDataSet1, '0', SinkDataSet1, '0']
- [StreamToDataSet2, '0', SinkDataSet2, '0']
- [SignalGenerator1, '0', SinkTriggered, '0']
- [SignalGenerator1, '0', SinkMultiplexed, '0']

metadata:
  file_format: 1
