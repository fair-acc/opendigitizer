blocks:
- name: SimpleTagSource
  id: opendigitizer::SimpleTagSource<float32>
  parameters:
    n_samples_max: '0'
    sample_rate: '100.'
    tag_indices: ['10', '20', '30', '40', '50', '60', '70', '80', '90', '100']
    tag_keys: [tag_id, tag_id, tag_id, tag_id, tag_id, tag_id, tag_id, tag_id, tag_id, tag_id]
    tag_values: ['10', '20', '30', '40', '50', '60', '70', '80', '90', '100']
  states: {}
- name: convertFloatDouble
  id: gr::blocks::type::converter::Convert<float32, float64>
  parameters: {}
  states: {}
- name: DataSink
  id: gr::basic::DataSink<float64>
  parameters:
    signal_name: test
  states: {}

connections:
- [SimpleTagSource, '0', convertFloatDouble, '0']
- [convertFloatDouble, '0', DataSink, '0']

metadata:
  file_format: 1
