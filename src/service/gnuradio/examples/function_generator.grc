blocks:
- name: ClockSource
  id: gr::basic::ClockSource<uint8, true, std::chrono::_V2::system_clock, true>
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    repeat_period: '2000000000'
    sample_rate: '1000'
    verbose_console: 'false'
    tag_times: ['10000000', '100000000', '300000000', '350000000', '550000000', '560000000', '650000000', '800000000', '850000000']
    tag_values: ['CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5', CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=8']
  states: {}
- name: FunctionGenerator
  id: gr::basic::FunctionGenerator<float32>
  parameters:
    sample_rate: '1000'
    signal_type: Const
    start_value: '0'
  states: {}
- name: DataSink
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: test
  states: {}

connections:
- [ClockSource, '0', FunctionGenerator, '0']
- [FunctionGenerator, '0', DataSink, '0']

metadata:
  file_format: 1
