blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    chunk_size: '100'
    do_zero_order_hold: 'true'
    n_samples_max: '100000000'
    repeat_period: '2000000000'
    sample_rate: '1000.000000'
    verbose_console: 'false'
    tag_times: ['10000000', '100000000', '300000000', '350000000', '550000000', '560000000', '650000000', '800000000', '850000000']
    tag_values: ['CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5', CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=8']
  states: {}
- name: FunctionGenerator
  id: gr::basic::FunctionGenerator
  parameters:
    duration: '0.000000'
    final_value: '0.000000'
    impulse_time0: '0.000000'
    impulse_time1: '0.000000'
    round_off_time: '0.000000'
    sample_rate: '1000.000000'
    signal_type: Const
    start_value: '0.000000'
  states: {}
- name: convertFloatDouble
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: DataSink
  id: gr::basic::DataSink
  parameters:
    signal_name: test
  states: {}

connections:
- [ClockSource, '0', FunctionGenerator, '0']
- [FunctionGenerator, '0', convertFloatDouble, '0']
- [convertFloatDouble, '0', DataSink, '0']

metadata:
  file_format: 1
