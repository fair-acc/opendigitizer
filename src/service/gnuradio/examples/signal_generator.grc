blocks:
- name: ClockSource
  id: gr::basic::ClockSource<uint8>
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    sample_rate: '4096'
    verbose_console: 'false'
  states: {}
- name: SignalGenerator1
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '0.125'
    amplitude: '20'
    sample_rate: '4096'
    signal_type: Triangle
  states: {}
- name: SignalGenerator2
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '1'
    amplitude: '5'
    sample_rate: '4096'
    signal_type: Sine
  states: {}
- name: Sum
  id: MultiAdder<float32>
  parameters:
    n_inputs: '2'
  states: {}
- name: DataSink
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: test
  states: {}

connections:
- [ClockSource, '0', SignalGenerator1, '0']
- [ClockSource, '0', SignalGenerator2, '0']
- [SignalGenerator1, '0', Sum, ['0', '0']]
- [SignalGenerator2, '0', Sum, ['0', '1']]
- [Sum, '0', DataSink, '0']

metadata:
  file_format: 1
