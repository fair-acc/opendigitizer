blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    chunk_size: '100'
    do_zero_order_hold: 'true'
    n_samples_max: '100000000'
    sample_rate: '4096.000000'
    verbose_console: 'false'
  states: {}
- name: SignalGenerator1
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '0.12500000'
    amplitude: '20.000000'
    offset: '0.000000'
    phase: '0.000000'
    sample_rate: '4096.000000'
    signal_type: Triangle
  states: {}
- name: SignalGenerator2
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '1.00000'
    amplitude: '5.000000'
    offset: '0.000000'
    phase: '0.000000'
    sample_rate: '4096.000000'
    signal_type: Sine
  states: {}
- name: Sum
  id: MultiAdder
  parameters:
    n_inputs: '2'
  states: {}
- name: convertFloatDouble
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: DataSink
  id: gr::basic::DataSink
  parameters:
    signal_name: test
  states: {}

connections:
- [ClockSource, '0', SignalGenerator1, '0']
- [ClockSource, '0', SignalGenerator2, '0']
- [SignalGenerator1, '0', Sum, ['0', '0']]
- [SignalGenerator2, '0', Sum, ['0', '1']]
- [Sum, '0', convertFloatDouble, '0']
- [convertFloatDouble, '0', DataSink, '0']

metadata:
  file_format: 1
