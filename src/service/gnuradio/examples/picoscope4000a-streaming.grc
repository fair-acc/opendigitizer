blocks:
- name: picoscope
  id: fair::picoscope::Picoscope4000a<float32, (fair::picoscope::AcquisitionMode)0>
  parameters:
    acquisition_mode: Streaming
    auto_arm: 'true'
    channel_couplings: [DC_1M, DC_1M, DC_1M, DC_1M]
    channel_ids: [A, B, C, D]
    channel_names: [test, signal B, signal C, signal D]
    channel_ranges: ['5', '5', '5', '5']
    channel_units: [Test unit A, Test unit B, Test unit C, Test unit D]
    sample_rate: '10000'
  states: {}
- name: sinkA
  id: gr::basic::DataSink<float32>
  parameters: {}
  states: {}
- name: sinkB
  id: gr::basic::DataSink<float32>
  parameters: {}
  states: {}
- name: sinkC
  id: gr::basic::DataSink<float32>
  parameters: {}
  states: {}
- name: sinkD
  id: gr::basic::DataSink<float32>
  parameters: {}
  states: {}

connections:
- [picoscope, ['0', '0'], sinkA, '0']
- [picoscope, ['0', '1'], sinkB, '0']
- [picoscope, ['0', '2'], sinkC, '0']
- [picoscope, ['0', '3'], sinkD, '0']

metadata:
  file_format: 1
