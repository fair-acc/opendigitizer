blocks:
- name: picoscope
  id: fair::picoscope::Picoscope4000a
  parameters:
    acquisition_mode: Streaming
    auto_arm: 'true'
    channel_couplings: [DC_1M]
    channel_ids: [A, B, C, D]
    channel_names: [signal A, signal B, signal C, signal D]
    channel_ranges: ['5', '5', '5', '5']
    channel_units: [Test unit A, Test unit B, Test unit C, Test unit D]
    sample_rate: '10000'
    streaming_mode_poll_rate: '0.000010'
  states: {}
- name: convertA
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: convertB
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: convertC
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: convertD
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: sinkA
  id: gr::basic::DataSink
  parameters:
    signal_name: test
  states: {}
- name: sinkB
  id: gr::basic::DataSink
  parameters:
    signal_name: signalB
  states: {}
- name: sinkC
  id: gr::basic::DataSink
  parameters:
    signal_name: signalC
  states: {}
- name: sinkD
  id: gr::basic::DataSink
  parameters:
    signal_name: signalD
  states: {}

connections:
- [picoscope, ['0', '0'], convertA, '0']
- [convertA, '0', sinkA, '0']
- [picoscope, ['0', '1'], convertB, '0']
- [convertB, '0', sinkB, '0']
- [picoscope, ['0', '2'], convertC, '0']
- [convertC, '0', sinkC, '0']
- [picoscope, ['0', '3'], convertD, '0']
- [convertD, '0', sinkD, '0']

metadata:
  file_format: 1
