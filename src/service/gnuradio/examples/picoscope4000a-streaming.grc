blocks:
- name: picoscope
  id: fair::picoscope::Picoscope4000a<float32>
  parameters:
    auto_arm: 'true'
    channel_couplings: [DC, DC, DC, DC]
    channel_ids: [A, B, C, D]
    channel_names: [test, SignalB, SignalC, SignalD]
    channel_ranges: ['5', '5', '5', '5']
    channel_units: [UnitA, UnitB, UnitC, UnitD]
    signal_quantities: [QuantityA, QuantityB, QuantityC, QuantityD]
    signal_scales: ['1', '1', '1', '1']
    signal_offsets: ['0', '0', '0', '0']
    sample_rate: '10000'
    trigger_source: A
    trigger_threshold: '0'
    trigger_direction: Rising
  states: {}
- name: DummySinkPicoDigital
  id: gr::testing::NullSink<uint16>
  parameters: {}
  states: {}
- name: sinkA
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: test
  states: {}
- name: sinkB
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: SignalB
  states: {}
- name: sinkC
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: SignalC
  states: {}
- name: sinkD
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: SignalD
  states: {}

connections:
- [picoscope, '0', DummySinkPicoDigital, '0']
- [picoscope, ['1', '0'], sinkA, '0']
- [picoscope, ['1', '1'], sinkB, '0']
- [picoscope, ['1', '2'], sinkC, '0']
- [picoscope, ['1', '3'], sinkD, '0']

metadata:
  file_format: 1
