blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    sample_rate: '1000'
    verbose_console: 'false'
    repeat_period: '1500000000'
    tag_times: ['1000000000']
    tag_values: [systemtime]
  states: {}
- name: SignalGeneratorA
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    offset: '0'
    phase: '0'
    sample_rate: '1000'
    signal_type: Sine
  states: {}
- name: SignalGeneratorD
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    offset: '0'
    phase: '0'
    sample_rate: '1000'
    signal_type: Sine
  states: {}
- name: NullSinkB
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkC
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkE
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: NullSinkF
  id: gr::testing::NullSink
  parameters: {}
  states: {}
- name: MultiplyConstA
  id: gr::blocks::math::MathOpImpl
  parameters:
    value: '1'
  states: {}
- name: MultiplyConstD
  id: gr::blocks::math::MathOpImpl
  parameters:
    value: '1'
  states: {}
- name: ConvertA
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertD
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: SinkA
  id: gr::basic::DataSink
  parameters:
    signal_name: U1
  states: {}
- name: SinkD
  id: gr::basic::DataSink
  parameters:
    signal_name: I1
  states: {}
- name: StreamToDataSetA
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '50'
    n_post: '50'
  states: {}
- name: StreamToDataSetD
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '50'
    n_post: '50'
  states: {}
- name: SinkDataSetA
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetU1
  states: {}
- name: SinkDataSetD
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetI1
  states: {}
- name: PowerMetrics
  id: gr::electrical::PowerMetrics
  parameters:
    decim: '1'
  states: {}
- name: SinkP1
  id: gr::basic::DataSink
  parameters:
    signal_name: P1
  states: {}
- name: SinkQ1
  id: gr::basic::DataSink
  parameters:
    signal_name: Q1
  states: {}
- name: SinkS1
  id: gr::basic::DataSink
  parameters:
    signal_name: S1
  states: {}
- name: PowerFactor
  id: gr::electrical::PowerFactor
  parameters: {}
  states: {}
- name: SinkPowerFactor1
  id: gr::basic::DataSink
  parameters:
    signal_name: PowerFactor1
  states: {}
- name: SinkPhase1
  id: gr::basic::DataSink
  parameters:
    signal_name: Phase1
  states: {}
- name: FrequencyEstimatorU1
  id: gr::filter::FrequencyEstimatorTimeDomain
  parameters: {}
  states: {}
- name: SinkFrequencyU1
  id: gr::basic::DataSink
  parameters:
    signal_name: FrequencyU1
  states: {}

connections:
- [ClockSource, '0', SignalGeneratorA, '0']
- [ClockSource, '0', SignalGeneratorD, '0']
- [SignalGeneratorA, '0', MultiplyConstA, '0']
- [MultiplyConstA, '0', ConvertA, '0']
- [ConvertA, '0', StreamToDataSetA, '0']
- [ConvertA, '0', SinkA, '0']
- [StreamToDataSetA, '0', SinkDataSetA, '0']
- [ConvertA, '0', SinkFrequencyU1, '0']
- [FrequencyEstimatorU1, '0', SinkFrequencyU1, '0']
- [SignalGeneratorD, '0', MultiplyConstD, '0']
- [MultiplyConstD, '0', ConvertD, '0']
- [ConvertD, '0', StreamToDataSetD, '0']
- [ConvertD, '0', SinkD, '0']
- [StreamToDataSetD, '0', SinkDataSetD, '0']
- [ConvertA, '0', PowerMetrics, ['0', '0']]
- [ConvertD, '0', PowerMetrics, ['1', '0']]
- [PowerMetrics, ['0', '0'], SinkP1, '0']
- [PowerMetrics, ['1', '0'], SinkQ1, '0']
- [PowerMetrics, ['2', '0'], SinkS1, '0']
- [PowerMetrics, ['0', '0'], PowerFactor, ['0', '0']]
- [PowerMetrics, ['2', '0'], PowerFactor, ['1', '0']]
- [PowerFactor, ['0', '0'], SinkPowerFactor1, '0']
- [PowerFactor, ['1', '0'], SinkPhase1, '0']

metadata:
  file_format: 1
