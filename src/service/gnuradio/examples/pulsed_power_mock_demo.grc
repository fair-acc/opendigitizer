blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    sample_rate: '1000'
    verbose_console: 'true'
    repeat_period: '1500000000'
    tag_times: ['1000000000']
    tag_values: [systemtime]
  states: {}
- name: SignalGeneratorA
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorB
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '2.0944'
  states: {}
- name: SignalGeneratorC
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '4.18879'
  states: {}
- name: SignalGeneratorD
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorE
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '2.0944'
  states: {}
- name: SignalGeneratorF
  id: gr::basic::SignalGenerator
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '4.18879'
  states: {}
- name: SignalGeneratorG
  id: gr::basic::SignalGenerator
  parameters:
    amplitude: '1'
    signal_type: Const
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorH
  id: gr::basic::SignalGenerator
  parameters:
    amplitude: '1'
    signal_type: Const
    sample_rate: '1000'
  states: {}
- name: ConvertA
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertB
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertC
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertD
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertE
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertF
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertG
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: ConvertH
  id: gr::blocks::type::converter::Convert
  parameters: {}
  states: {}
- name: SinkA
  id: gr::basic::DataSink
  parameters:
    signal_name: U1
  states: {}
- name: SinkB
  id: gr::basic::DataSink
  parameters:
    signal_name: U2
  states: {}
- name: SinkC
  id: gr::basic::DataSink
  parameters:
    signal_name: U3
  states: {}
- name: SinkD
  id: gr::basic::DataSink
  parameters:
    signal_name: I1
  states: {}
- name: SinkE
  id: gr::basic::DataSink
  parameters:
    signal_name: I2
  states: {}
- name: SinkF
  id: gr::basic::DataSink
  parameters:
    signal_name: I3
  states: {}
- name: SinkG
  id: gr::basic::DataSink
  parameters:
    signal_name: PicoG
  states: {}
- name: SinkH
  id: gr::basic::DataSink
  parameters:
    signal_name: TT
  states: {}
- name: StreamToDataSetA
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetB
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetC
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetD
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetE
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetF
  id: gr::basic::StreamFilterImpl
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: SinkDataSetA
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetU1
  states: {}
- name: SinkDataSetB
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetU2
  states: {}
- name: SinkDataSetC
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetU3
  states: {}
- name: SinkDataSetD
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetI1
  states: {}
- name: SinkDataSetE
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetI2
  states: {}
- name: SinkDataSetF
  id: gr::basic::DataSetSink
  parameters:
    signal_name: DataSetI3
  states: {}
- name: PowerMetrics
  id: gr::electrical::PowerMetrics
  parameters:
    decim: '1'
  states: {}
- name: SystemUnbalance
  id: gr::electrical::SystemUnbalance
  parameters: {}
  states: {}
- name: SinkTotalActivePower
  id: gr::basic::DataSink
  parameters:
    signal_name: TotalActivePower
  states: {}
- name: FrequencyEstimatorU1
  id: gr::filter::FrequencyEstimatorTimeDomain
  parameters: {}
  states: {}
- name: SinkFrequencyU1
  id: gr::basic::DataSink
  parameters:
    signal_name: FrequencyU1
  states: {}

connections:
- [ClockSource, '0', SignalGeneratorA, '0']
- [ClockSource, '0', SignalGeneratorB, '0']
- [ClockSource, '0', SignalGeneratorC, '0']
- [ClockSource, '0', SignalGeneratorD, '0']
- [ClockSource, '0', SignalGeneratorE, '0']
- [ClockSource, '0', SignalGeneratorF, '0']
- [ClockSource, '0', SignalGeneratorG, '0']
- [ClockSource, '0', SignalGeneratorH, '0']
- [SignalGeneratorA, '0', ConvertA, '0']
- [ConvertA, '0', SinkA, '0']
- [ConvertA, '0', StreamToDataSetA, '0']
- [StreamToDataSetA, '0', SinkDataSetA, '0']
- [ConvertA, '0', FrequencyEstimatorU1, '0']
- [FrequencyEstimatorU1, '0', SinkFrequencyU1, '0']
- [SignalGeneratorB, '0', ConvertB, '0']
- [ConvertB, '0', SinkB, '0']
- [ConvertB, '0', StreamToDataSetB, '0']
- [StreamToDataSetB, '0', SinkDataSetB, '0']
- [SignalGeneratorC, '0', ConvertC, '0']
- [ConvertC, '0', SinkC, '0']
- [ConvertC, '0', StreamToDataSetC, '0']
- [StreamToDataSetC, '0', SinkDataSetC, '0']
- [SignalGeneratorD, '0', ConvertD, '0']
- [ConvertD, '0', SinkD, '0']
- [ConvertD, '0', StreamToDataSetD, '0']
- [StreamToDataSetD, '0', SinkDataSetD, '0']
- [SignalGeneratorE, '0', ConvertE, '0']
- [ConvertE, '0', SinkE, '0']
- [ConvertE, '0', StreamToDataSetE, '0']
- [StreamToDataSetE, '0', SinkDataSetE, '0']
- [SignalGeneratorF, '0', ConvertF, '0']
- [ConvertF, '0', SinkF, '0']
- [ConvertF, '0', StreamToDataSetF, '0']
- [StreamToDataSetF, '0', SinkDataSetF, '0']
- [SignalGeneratorG, '0', ConvertG, '0']
- [ConvertG, '0', SinkG, '0']
- [SignalGeneratorH, '0', ConvertH, '0']
- [ConvertH, '0', SinkH, '0']
- [ConvertA, '0', PowerMetrics, ['0', '0']]
- [ConvertB, '0', PowerMetrics, ['0', '1']]
- [ConvertC, '0', PowerMetrics, ['0', '2']]
- [ConvertD, '0', PowerMetrics, ['1', '0']]
- [ConvertE, '0', PowerMetrics, ['1', '1']]
- [ConvertF, '0', PowerMetrics, ['1', '2']]
- [PowerMetrics, ['3', '0'], SystemUnbalance, ['0', '0']]
- [PowerMetrics, ['3', '1'], SystemUnbalance, ['0', '1']]
- [PowerMetrics, ['3', '2'], SystemUnbalance, ['0', '2']]
- [PowerMetrics, ['4', '0'], SystemUnbalance, ['1', '0']]
- [PowerMetrics, ['4', '1'], SystemUnbalance, ['1', '1']]
- [PowerMetrics, ['4', '2'], SystemUnbalance, ['1', '2']]
- [PowerMetrics, ['0', '0'], SystemUnbalance, ['2', '0']]
- [PowerMetrics, ['0', '1'], SystemUnbalance, ['2', '1']]
- [PowerMetrics, ['0', '2'], SystemUnbalance, ['2', '2']]
- [SystemUnbalance, '0', SinkTotalActivePower, '0']

metadata:
  file_format: 1
