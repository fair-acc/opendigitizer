blocks:
- name: ClockSource
  id: gr::basic::ClockSource<uint8, true, std::chrono::_V2::system_clock, true>
  parameters:
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    sample_rate: '1000'
    verbose_console: 'true'
    repeat_period: '1500000000'
    chunk_size: '250'
    tag_times: ['1000000000']
    tag_values: [systemtime]
  states: {}
- name: SignalGeneratorA
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorB
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '2.0944'
  states: {}
- name: SignalGeneratorC
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '4.18879'
  states: {}
- name: SignalGeneratorD
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorE
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '2.0944'
  states: {}
- name: SignalGeneratorF
  id: gr::basic::SignalGenerator<float32>
  parameters:
    frequency: '50'
    amplitude: '5'
    signal_type: Sine
    sample_rate: '1000'
    phase: '4.18879'
  states: {}
- name: SignalGeneratorG
  id: gr::basic::SignalGenerator<float32>
  parameters:
    amplitude: '1'
    signal_type: Const
    sample_rate: '1000'
  states: {}
- name: SignalGeneratorH
  id: gr::basic::SignalGenerator<float32>
  parameters:
    amplitude: '1'
    signal_type: Const
    sample_rate: '1000'
  states: {}
- name: SinkA
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U1
  states: {}
- name: SinkB
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U2
  states: {}
- name: SinkC
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: U3
  states: {}
- name: SinkD
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I1
  states: {}
- name: SinkE
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I2
  states: {}
- name: SinkF
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: I3
  states: {}
- name: SinkG
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: PicoG
  states: {}
- name: SinkH
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: TT
  states: {}
- name: StreamToDataSetA
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetB
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetC
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetD
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetE
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: StreamToDataSetF
  id: gr::basic::StreamFilterImpl<float32, false, gr::trigger::BasicTriggerNameCtxMatcher::Filter>
  parameters:
    filter: systemtime
    n_pre: '10'
    n_post: '50'
  states: {}
- name: SinkDataSetA
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU1
  states: {}
- name: SinkDataSetB
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU2
  states: {}
- name: SinkDataSetC
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetU3
  states: {}
- name: SinkDataSetD
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI1
  states: {}
- name: SinkDataSetE
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI2
  states: {}
- name: SinkDataSetF
  id: gr::basic::DataSetSink<float32>
  parameters:
    signal_name: DataSetI3
  states: {}
- name: PowerMetrics
  id: gr::electrical::PowerMetrics<float32, 3ul>
  parameters:
    decim: '1'
  states: {}
- name: SystemUnbalance
  id: gr::electrical::SystemUnbalance<float32, 3ul>
  parameters: {}
  states: {}
- name: SinkTotalActivePower
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: TotalActivePower
  states: {}
- name: FrequencyEstimatorU1
  id: gr::filter::FrequencyEstimatorTimeDomain<float32>
  parameters: {}
  states: {}
- name: SinkFrequencyU1
  id: gr::basic::DataSink<float32>
  parameters:
    signal_name: FrequencyU1
  states: {}
- name: DummySinkPQS10
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkPQS11
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkPQS12
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkPQS20
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkPQS21
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkPQS22
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkUnbalance1
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}
- name: DummySinkUnbalance2
  id: gr::testing::TagSink<float32, (gr::testing::ProcessFunction)0>
  parameters:
    logTags: 'false'
    logSamples: 'false'
  states: {}

connections:
- [ClockSource, '0', SignalGeneratorA, '0']
- [ClockSource, '0', SignalGeneratorB, '0']
- [ClockSource, '0', SignalGeneratorC, '0']
- [ClockSource, '0', SignalGeneratorD, '0']
- [ClockSource, '0', SignalGeneratorE, '0']
- [ClockSource, '0', SignalGeneratorF, '0']
- [ClockSource, '0', SignalGeneratorG, '0']
- [ClockSource, '0', SignalGeneratorH, '0']
- [SignalGeneratorA, '0', SinkA, '0']
- [SignalGeneratorA, '0', StreamToDataSetA, '0']
- [StreamToDataSetA, '0', SinkDataSetA, '0']
- [SignalGeneratorA, '0', FrequencyEstimatorU1, '0']
- [FrequencyEstimatorU1, '0', SinkFrequencyU1, '0']
- [SignalGeneratorB, '0', SinkB, '0']
- [SignalGeneratorB, '0', StreamToDataSetB, '0']
- [StreamToDataSetB, '0', SinkDataSetB, '0']
- [SignalGeneratorC, '0', SinkC, '0']
- [SignalGeneratorC, '0', StreamToDataSetC, '0']
- [StreamToDataSetC, '0', SinkDataSetC, '0']
- [SignalGeneratorD, '0', SinkD, '0']
- [SignalGeneratorD, '0', StreamToDataSetD, '0']
- [StreamToDataSetD, '0', SinkDataSetD, '0']
- [SignalGeneratorE, '0', SinkE, '0']
- [SignalGeneratorE, '0', StreamToDataSetE, '0']
- [StreamToDataSetE, '0', SinkDataSetE, '0']
- [SignalGeneratorF, '0', SinkF, '0']
- [SignalGeneratorF, '0', StreamToDataSetF, '0']
- [StreamToDataSetF, '0', SinkDataSetF, '0']
- [SignalGeneratorG, '0', SinkG, '0']
- [SignalGeneratorH, '0', SinkH, '0']
- [SignalGeneratorA, '0', PowerMetrics, ['0', '0']]
- [SignalGeneratorB, '0', PowerMetrics, ['0', '1']]
- [SignalGeneratorC, '0', PowerMetrics, ['0', '2']]
- [SignalGeneratorD, '0', PowerMetrics, ['1', '0']]
- [SignalGeneratorE, '0', PowerMetrics, ['1', '1']]
- [SignalGeneratorF, '0', PowerMetrics, ['1', '2']]
- [PowerMetrics, ['3', '0'], SystemUnbalance, ['0', '0']]
- [PowerMetrics, ['3', '1'], SystemUnbalance, ['0', '1']]
- [PowerMetrics, ['3', '2'], SystemUnbalance, ['0', '2']]
- [PowerMetrics, ['4', '0'], SystemUnbalance, ['1', '0']]
- [PowerMetrics, ['4', '1'], SystemUnbalance, ['1', '1']]
- [PowerMetrics, ['4', '2'], SystemUnbalance, ['1', '2']]
- [PowerMetrics, ['0', '0'], SystemUnbalance, ['2', '0']]
- [PowerMetrics, ['0', '1'], SystemUnbalance, ['2', '1']]
- [PowerMetrics, ['0', '2'], SystemUnbalance, ['2', '2']]
- [PowerMetrics, ['1', '0'], DummySinkPQS10, '0']
- [PowerMetrics, ['1', '1'], DummySinkPQS11, '0']
- [PowerMetrics, ['1', '2'], DummySinkPQS12, '0']
- [PowerMetrics, ['2', '0'], DummySinkPQS20, '0']
- [PowerMetrics, ['2', '1'], DummySinkPQS21, '0']
- [PowerMetrics, ['2', '2'], DummySinkPQS22, '0']
- [SystemUnbalance, '0', SinkTotalActivePower, '0']
- [SystemUnbalance, '1', DummySinkUnbalance1, '0']
- [SystemUnbalance, '2', DummySinkUnbalance2, '0']

metadata:
  file_format: 1
