blocks:
- name: Sum1
  id: opendigitizer::Arithmetic<float32>
  parameters: {}
  states: {}
- name: FFT
  id: gr::blocks::fft::FFT<float32, gr::DataSet<float32>, gr::algorithm::FFT>
  parameters:
    outputInDb: 'true'
    outputInDeg: 'true'
    unwrapPhase: 'true'
  states: {}
- name: SineSource1
  id: opendigitizer::SineSource<float32>
  parameters:
    frequency: '2'
  states: {}
- name: SineSource2
  id: opendigitizer::SineSource<float32>
  parameters:
    frequency: '5'
  states: {}
- name: SineSink1
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0xFF0000'
    signal_name: value
    signal_quantity: voltage
    signal_unit: V
  states: {}
- name: SineSink2
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0x000099'
    signal_name: value
    signal_quantity: voltage
    signal_unit: V
  states: {}
- name: SumSink1
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0x00C800'
    signal_name: value
    signal_quantity: voltage
    signal_unit: V
  states: {}
- name: fftSink
  id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
  parameters:
    color: '0xFF5500'
    dataset_index: '0'
    signal_name: fft
    signal_quantity: magnitude
    signal_unit: dB
  states: {}
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    chunk_size: '20'
    do_zero_order_hold: 'true'
    n_samples_max: '0'
    repeat_period: '4000000000'
    sample_rate: '1000'
    verbose_console: 'false'
    tag_times: ['10000000', '100000000', '200000000', '500000000', '1000000000', '2000000000', '3000000000', '3900000000']
    tag_values: ['CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5', CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7']
  states: {}
- name: DipoleCurrentGenerator
  id: gr::basic::FunctionGenerator<float32>
  parameters:
    sample_rate: '1000'
    signal_type: Const
    start_value: '0'
    signal_trigger: CMD_BP_START
  states: {}
- name: IntensityGenerator
  id: gr::basic::FunctionGenerator<float32>
  parameters:
    sample_rate: '1000'
    signal_type: Const
    start_value: '0'
    signal_trigger: CMD_BP_START
  states: {}
- name: DipoleCurrentSink
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0xC80000'
    required_size: '16384'
    signal_name: dipole current
    signal_quantity: DipoleCurrent
    signal_unit: A
  states: {}
- name: IntensitySink
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0x0000C8'
    required_size: '16384'
    signal_name: beam intensity
    signal_quantity: BeamIntensity
    signal_unit: ppp
  states: {}

connections:
- [SineSource1, '0', Sum1, '0']
- [SineSource2, '0', Sum1, '1']
- [SineSource1, '0', SineSink1, '0']
- [SineSource2, '0', SineSink2, '0']
- [Sum1, '0', FFT, '0']
- [Sum1, '0', SumSink1, '0']
- [FFT, '0', fftSink, '0']
- [ClockSource, '0', DipoleCurrentGenerator, '0']
- [DipoleCurrentGenerator, '0', DipoleCurrentSink, '0']
- [ClockSource, '0', IntensityGenerator, '0']
- [IntensityGenerator, '0', IntensitySink, '0']

metadata:
  file_format: 1
