blocks:
- name: sum sigs
  id: opendigitizer::Arithmetic
  parameters: {}
  states: {}
- name: FFT
  id: gr::blocks::fft::FFT
  parameters: {}
  states: {}
- name: sine source 1
  id: opendigitizer::SineSource
  parameters:
    frequency: '2.000000'
  states: {}
- name: sine source 3
  id: opendigitizer::SineSource
  parameters:
    frequency: '5.00000'
  states: {}
- name: sink 1
  id: opendigitizer::ImPlotSink
  parameters:
    color: '0xff0000'
  states: {}
- name: sink 2
  id: opendigitizer::ImPlotSinkDataSet
  parameters:
    color: '0x00ff00'
    dataset_index: '3'
  states: {}
- name: sink 3
  id: opendigitizer::ImPlotSink
  parameters:
    color: '0xffff00'
  states: {}
- name: sink 4
  id: opendigitizer::ImPlotSink
  parameters:
    color: '0x00ff00'
  states: {}

connections:
- [sine source 1, '0', sum sigs, '0']
- [sine source 3, '0', sum sigs, '1']
- [sum sigs, '0', FFT, '0']
- [sum sigs, '0', sink 1, '0']
- [FFT, '0', sink 2, '0']
- [sine source 1, '0', sink 3, '0']
- [sine source 3, '0', sink 4, '0']

metadata:
  file_format: 1
