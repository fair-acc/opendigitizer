blocks:
- name: sum sigs
  id: Arithmetic
  parameters: {}
  states: {}
- name: FFT
  id: FFT
  parameters: {}
  states: {}
- name: sine source 1
  id: sine_source
  parameters:
    frequency: '1.000000'
  states: {}
- name: sine source 3
  id: sine_source
  parameters:
    frequency: '1.300000'
  states: {}
- name: sink 1
  id: sink
  parameters: {}
  states: {}
- name: sink 2
  id: sink
  parameters: {}
  states: {}

connections:
- [sine source 1, '0', sum sigs, '0']
- [sine source 3, '0', sum sigs, '1']
- [sum sigs, '0', FFT, '0']
- [sum sigs, '0', sink 1, '0']
- [FFT, '0', sink 2, '0']

metadata:
  file_format: 1
