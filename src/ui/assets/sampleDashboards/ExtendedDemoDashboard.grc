blocks:
- name: sum sigs1
  id: opendigitizer::Arithmetic
  parameters: {}
  states: {}
- name: sum sigs2
  id: opendigitizer::Arithmetic
  parameters: {}
  states: {}
- name: sum sigs3
  id: opendigitizer::Arithmetic
  parameters: {}
  states: {}
- name: FFT
  id: FFT
  parameters: {}
  states: {}
- name: sine source 3
  id: opendigitizer::SineSource
  parameters:
    frequency: '0.100000'
  states: {}
- name: sine source 4
  id: opendigitizer::SineSource
  parameters:
    frequency: '0.200000'
  states: {}
- name: sine source 5
  id: opendigitizer::SineSource
  parameters:
    frequency: '0.300000'
  states: {}
- name: sine source 6
  id: opendigitizer::SineSource
  parameters:
    frequency: '0.400000'
  states: {}
- name: source for sink 1
  id: sink_source
  parameters: {}
  states: {}
- name: source for sink 2
  id: sink_source
  parameters: {}
  states: {}
- name: sink 1
  id: sink
  parameters: {}
  states: {}
- name: sink 2
  id: sink
  parameters: {}
  states: {}
- name: sink 3
  id: sink
  parameters: {}
  states: {}
- name: sink 4
  id: sink
  parameters: {}
  states: {}
- name: sink 5
  id: sink
  parameters: {}
  states: {}
- name: sink 6
  id: sink
  parameters: {}
  states: {}

connections:
- [sine source 3, '0', sum sigs1, '0']
- [sine source 4, '0', sum sigs1, '1']
- [sine source 5, '0', sum sigs2, '0']
- [sine source 6, '0', sum sigs2, '1']
- [sum sigs1, '0', sum sigs3, '0']
- [sum sigs2, '0', sum sigs3, '1']
- [sum sigs3, '0', FFT, '0']
- [FFT, '0', sink 2, '0']
- [sum sigs3, '0', sink 1, '0']
- [sine source 3, '0', sink 3, '0']
- [sine source 4, '0', sink 4, '0']
- [sine source 5, '0', sink 5, '0']
- [sine source 6, '0', sink 6, '0']

metadata:
  file_format: 1
