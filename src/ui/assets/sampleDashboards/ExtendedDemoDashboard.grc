blocks:
  - id: opendigitizer::Arithmetic<float32>
    parameters:
      name: sineSum1
  - id: opendigitizer::Arithmetic<float32>
    parameters:
      name: sineSum2
  - id: opendigitizer::Arithmetic<float32>
    parameters:
      name: sineSum3
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: sineSum4
      n_inputs: 3
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: sineSum5
      n_inputs: 4
  - id: gr::blocks::fft::FFT<float32>
    parameters:
      name: FFT
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: sineSource1
      signal_type: Sin
      frequency: 0.1
      sample_rate: 1000
      chunk_size: 40
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: sineSource2
      signal_type: Sin
      frequency: 0.2
      sample_rate: 1000
      chunk_size: 40
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: sineSource3
      signal_type: Sin
      frequency: 0.3
      sample_rate: 1000
      chunk_size: 40
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: sineSource4
      signal_type: Sin
      frequency: 0.4
      sample_rate: 1000
      chunk_size: 40
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sinesSink
      color: 0xff0000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: fftSink
      color: 0x00ff00
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sineSink1
      color: 0x0000ff
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sineSink2
      color: 0xffff00
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sineSink3
      color: 0x00ffff
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sineSink4
      color: 0xff00ff
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sineSum5Sink
      color: 0xff8000
connections:
  - [sineSource1, 0, sineSum1, 0]
  - [sineSource2, 0, sineSum1, 1]
  - [sineSource3, 0, sineSum2, 0]
  - [sineSource4, 0, sineSum2, 1]
  - [sineSum1, 0, sineSum3, 0]
  - [sineSum2, 0, sineSum3, 1]
  - [sineSum3, 0, sineSum4, [0, 0]]
  - [sineSource1, 0, sineSum4, [0, 1]]
  - [sineSource2, 0, sineSum4, [0, 2]]
  - [sineSum4, 0, FFT, 0]
  - [FFT, 0, fftSink, 0]
  - [sineSum4, 0, sinesSink, 0]
  - [sineSource1, 0, sineSink1, 0]
  - [sineSource2, 0, sineSink2, 0]
  - [sineSource3, 0, sineSink3, 0]
  - [sineSource4, 0, sineSink4, 0]
  - [sineSource1, 0, sineSum5, [0, 0]]
  - [sineSource2, 0, sineSum5, [0, 1]]
  - [sineSource3, 0, sineSum5, [0, 2]]
  - [sineSource4, 0, sineSum5, [0, 3]]
  - [sineSum5, 0, sineSum5Sink, 0]
dashboard:
  layout: Free
  sources:
    - name: sineSink1
      block: sineSink1
      color: !!uint32 0xff0000
    - name: sineSink2
      block: sineSink2
      color: !!uint32 0x00ff00
    - name: sineSink3
      block: sineSink3
      color: !!uint32 0x0000ff
    - name: sineSink4
      block: sineSink4
      color: !!uint32 0xffff00
    - name: sinesSink
      block: sinesSink
      color: !!uint32 0x00ffff
    - name: fftSink
      block: fftSink
      color: !!uint32 0xff00ff
    - name: sineSum5Sink
      block: sineSum5Sink
      color: !!uint32 0xff8000
  plots:
    - name: Plot 4
      sources:
        - sineSink1
      rect: [0, 0, 8, 4]
    - name: Plot 5
      sources:
        - sinesSink
      rect: [8, 0, 8, 8]
    - name: Plot 6
      sources:
        - sineSink2
      rect: [0, 4, 8, 4]
    - name: Plot 7
      sources:
        - fftSink
      rect: [8, 8, 8, 8]
    - name: Plot 8
      sources:
        - sineSink3
      rect: [0, 8, 8, 4]
    - name: Plot 9
      sources:
        - sineSink4
      rect: [0, 12, 8, 4]
    - name: Plot 10
      sources:
        - sineSum5Sink
      rect: [0, 16, 16, 4]
  flowgraphLayout: ""
