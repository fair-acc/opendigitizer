blocks:
  - id: gr::basic::ClockSource
    parameters:
      name: ClockSource1
      n_samples_max: 0
      sample_rate: 4096
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: SignalGenerator1
      frequency: 1
      amplitude: 5
      sample_rate: 4096
      signal_type: Sin
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink1
      color: 0xFF0000
  - id: DigitizerUi::SchedulerStateIndicator
    parameters:
      name: status_b_indicator
  - id: ForeignStatusBlock
    parameters:
      name: status_c_foreign
  - id: TestStatusText
    parameters:
      name: status_a_text
connections:
  - [ClockSource1, 0, SignalGenerator1, 0]
  - [SignalGenerator1, 0, PlotSink1, 0]
dashboard:
  layout: Free
  sources: []
  plots: []
