blocks:
  - id: gr::basic::ClockSource
    parameters:
      name: ClockSource1
      n_samples_max: 0
      sample_rate: 4096
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: SignalGenerator1
      frequency: 1
      amplitude: 5
      sample_rate: 4096
      signal_type: Sin
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: SignalGenerator2
      frequency: 2
      amplitude: 3
      sample_rate: 4096
      signal_type: Sin
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink1
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink2
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: control_a_field
      label: Amplitude
      unit: V
      value_type: float32
      value: 1
      style: field
      target_map: "SignalGenerator1,SignalGenerator2:amplitude"
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: control_b_spin
      label: Frequency
      value_type: float32
      value: 1
      step: 1
      style: spinBox
      target_map: "SignalGenerator1:frequency"
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: control_c_slider
      label: Level
      value_type: float32
      value: 2
      min: 0
      max: 10
      style: slider
      target_map: "SignalGenerator2:frequency"
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: control_d_sliderSpinner
      label: Gain
      unit: "%"
      value_type: float64
      value: 50
      min: 0
      max: 100
      style: sliderSpinner
      target_map: "*:amplitude"
connections:
  - [ClockSource1, 0, SignalGenerator1, 0]
  - [SignalGenerator1, 0, PlotSink1, 0]
  - [ClockSource1, 0, SignalGenerator2, 0]
  - [SignalGenerator2, 0, PlotSink2, 0]
dashboard:
  layout: Free
  sources: []
  plots: []
