blocks:
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: source
  - id: gr::testing::Copy<float32>
    parameters:
      name: middleA
  - id: gr::testing::Copy<float32>
    parameters:
      name: middleB
  - id: gr::testing::AtomicCountingSink<float32>
    parameters:
      name: sink
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: loner1
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: loner2
connections:
  - [source, 0, middleA, 0]
  - [middleA, 0, middleB, 0]
  - [middleB, 0, sink, 0]
dashboard: { sources: [], plots: [] }
