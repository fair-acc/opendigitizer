blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    chunk_size: '20'
    do_zero_order_hold: 'true'
    n_samples_max: '10000'
    repeat_period: '4000000000'
    sample_rate: '1000'
    verbose_console: 'false'
    tag_times: ['10000000', '100000000', '200000000', '500000000', '1000000000', '2000000000', '3000000000', '3900000000']
    tag_values: ['CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5', CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7']
  states: {}
- name: DipoleCurrentGenerator
  id: gr::basic::FunctionGenerator<float32>
  parameters:
    sample_rate: '1000'
    signal_type: Const
    start_value: '0'
    signal_trigger: CMD_BP_START
  states: {}
- name: IntensityGenerator
  id: gr::basic::FunctionGenerator<float32>
  parameters:
    sample_rate: '1000'
    signal_type: Const
    start_value: '0'
    signal_trigger: CMD_BP_START
  states: {}
- name: toDipoleDataSet
  id: gr::basic::StreamToDataSet<float32, false>
  parameters:
    filter: '[CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2, CMD_BP_START/^FAIR.SELECTOR.C=1:S=1:P=5]'
    n_pre: '100'
    n_post: '0'
    n_max: '100000'
  states: {}
- name: toIntensityDataSet
  id: gr::basic::StreamToDataSet<float32, false>
  parameters:
    filter: '[CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2, CMD_BP_START/^FAIR.SELECTOR.C=1:S=1:P=5]'
    n_pre: '100'
    n_post: '0'
    n_max: '100000'
  states: {}
- name: DipoleCurrentSink
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0xC80000'
    required_size: '8192'
    signal_name: dipole current
    signal_quantity: DipoleCurrent
    signal_unit: A
  states: {}
- name: DipoleCurrentDataSetSink
  id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
  parameters:
    color: '0xC80000'
    required_size: '32'
    signal_name: dipole current - cycle
    signal_quantity: DipoleCurrent
    signal_unit: A
    n_history: '3'
    history_offset: '0.02'
  states: {}
- name: IntensitySink
  id: opendigitizer::ImPlotSink<float32>
  parameters:
    color: '0x0000C8'
    required_size: '8192'
    signal_name: beam intensity
    signal_quantity: BeamIntensity
    signal_unit: ppp
  states: {}
- name: IntensityDataSetSink
  id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
  parameters:
    color: '0x0000C8'
    required_size: '32'
    signal_name: beam intensity - cycle
    signal_quantity: BeamIntensity
    signal_unit: ppp
    n_history: '3'
    history_offset: '0.02'
  states: {}

connections:
- [ClockSource, '0', DipoleCurrentGenerator, '0']
- [DipoleCurrentGenerator, '0', DipoleCurrentSink, '0']
- [DipoleCurrentGenerator, '0', toDipoleDataSet, '0']
- [toDipoleDataSet, '0', DipoleCurrentDataSetSink, '0']
- [ClockSource, '0', IntensityGenerator, '0']
- [IntensityGenerator, '0', IntensitySink, '0']
- [IntensityGenerator, '0', toIntensityDataSet, '0']
- [toIntensityDataSet, '0', IntensityDataSetSink, '0']

metadata:
  file_format: 1
