blocks:
- name: ClockSource
  id: gr::basic::ClockSource
  parameters:
    chunk_size: '100'
    do_zero_order_hold: 'true'
    n_samples_max: '100000000'
    repeat_period: '2000000000'
    sample_rate: '1000.000000'
    verbose_console: 'false'
    tag_times: ['10000000', '100000000', '300000000', '350000000', '550000000', '560000000', '650000000', '800000000', '850000000']
    tag_values: ['CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=1', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=2', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=3', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=4', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=5', CMD_DIAG_TRIGGER1, 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=6', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=7', 'CMD_BP_START/FAIR.SELECTOR.C=1:S=1:P=8']
  states: {}
- name: DipoleCurrentGenerator
  id: gr::basic::FunctionGenerator
  parameters:
    duration: '0.000000'
    final_value: '0.000000'
    impulse_time0: '0.000000'
    impulse_time1: '0.000000'
    round_off_time: '0.000000'
    sample_rate: '1000.000000'
    signal_type: Const
    start_value: '0.000000'
  states: {}
- name: DipoleCurrentSink
  id: opendigitizer::ImPlotSink
  parameters:
    signal_name: dipole current
    signal_unit: A
  states: {}

connections:
- [ClockSource, '0', DipoleCurrentGenerator, '0']
- [DipoleCurrentGenerator, '0', DipoleCurrentSink, '0']

metadata:
  file_format: 1
