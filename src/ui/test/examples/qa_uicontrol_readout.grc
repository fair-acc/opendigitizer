blocks:
  - id: gr::basic::ClockSource
    parameters:
      name: clockSource1
      n_samples_max: 0
      sample_rate: 4096
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: signalGenerator1
      frequency: 1
      sample_rate: 4096
      signal_type: Sin
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: sinkA
      visible: true
      signal_name: alpha
      signal_quantity: voltage
  - id: DigitizerUi::ImControlText
    parameters:
      name: controlName
      label: Name
      value: alpha
      target_map: "sinkA:signal_name"
  - id: DigitizerUi::ImPropertyReadout
    parameters:
      name: readoutQuantity
      label: Quantity
      target_map: "sinkA:signal_quantity"
connections:
  - [clockSource1, 0, signalGenerator1, 0]
  - [signalGenerator1, 0, sinkA, 0]
dashboard:
  layout: Free
  sources: []
  plots: []
