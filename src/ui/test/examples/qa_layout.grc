blocks:
  - id: gr::basic::ClockSource
    parameters:
      name: ClockSource1
      do_zero_order_hold: true
      n_samples_max: 0
      sample_rate: 4096
      verbose_console: false
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: SignalGenerator1
      frequency: 1
      amplitude: 5
      sample_rate: 4096
      signal_type: Sin
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink1
      color: 0xFF0000
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink2
      color: 0x00FF00
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink3
      color: 0x0000FF
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink4
      color: 0xAAAA00
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink5
      color: 0x00AAAA
  - id: opendigitizer::ImPlotSink<float32>
    parameters:
      name: PlotSink6
      color: 0xAA00AA
connections:
  - [ClockSource1, 0, SignalGenerator1, 0]
  - [SignalGenerator1, 0, PlotSink1, 0]
  - [SignalGenerator1, 0, PlotSink2, 0]
  - [SignalGenerator1, 0, PlotSink3, 0]
  - [SignalGenerator1, 0, PlotSink4, 0]
  - [SignalGenerator1, 0, PlotSink5, 0]
  - [SignalGenerator1, 0, PlotSink6, 0]
dashboard:
  layout: Free
  sources:
    - name: PlotSink1
      block: PlotSink1
      port: 0
      color: 0xFF0000
    - name: PlotSink2
      block: PlotSink2
      port: 0
      color: 0x00FF00
    - name: PlotSink3
      block: PlotSink3
      port: 0
      color: 0x0000FF
    - name: PlotSink4
      block: PlotSink4
      port: 0
      color: 0xAAAA00
    - name: PlotSink5
      block: PlotSink5
      port: 0
      color: 0x00AAAA
    - name: PlotSink6
      block: PlotSink6
      port: 0
      color: 0xAA00AA
  plots:
    - name: Plot1
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink1
      rect: [0, 0, 3, 1] # x, y, width, height
    - name: Plot2
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink2
      rect: [3, 0, 1, 1] # x, y, width, height
    - name: Plot3
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink3
      rect: [0, 1, 2, 1] # x, y, width, height
    - name: Plot4
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink4
      rect: [2, 1, 2, 2] # x, y, width, height
    - name: Plot5
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink5
      rect: [0, 2, 2, 1] # x, y, width, height
    - name: Plot6
      axes:
        - axis: X
          min: NaN
          max: NaN
          scale: Linear
        - axis: Y
          min: NaN
          max: NaN
      sources:
        - PlotSink6
      rect: [0, 3, 4, 1] # x, y, width, height
