connections:  []
blocks:
  - scheduler:
      id:  "gr::scheduler::Simple<gr::scheduler::ExecutionPolicy::singleThreaded>"
    block_category:  "ScheduledBlockGroup"
    parameters:
      name: "simpleScheduler"
    name:  "gr::scheduler::Simple<gr::scheduler::ExecutionPolicy::singleThreaded>"
    graph:
      exported_ports:  []
      connections:  []
      blocks:
        - parameters:
            disconnect_on_done: !!bool true
            ui_constraints:
              y: !!float32 29
              x: !!float32 -392
            name:  "subgraphSineSource"
          id:  "opendigitizer::SineSource<float32>"
        - parameters:
            disconnect_on_done: !!bool true
            ui_constraints:
              y: !!float32 194
              x: !!float32 553
            name:  "gr::basic::DataSink<float32>"
          id:  "gr::basic::DataSink<float32>"
    id:  "SUBGRAPH"
dashboard: { sources: [], plots: [] }
